<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\3D_Coil_Receiver_V0.ewp</path>
  </project>
  <batchBuild />
</workspace>
